# Keil uVision project AirDrum_HAL.uvprojx, settings and files
target STM32F4DISCOVERY (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB_CDC
  c flags: Optim=4 wLevel=2
  c define: HSE_VALUE=8000000,USE_HAL_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App/User
    ./: main.c USBD_User_CDC_0.c midi.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group App/MCU9150
    ./: mpu9150_hal.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::CMSIS Driver
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/CMSIS/Driver/: OTG_FS_STM32F4xx.c USBD_FS_STM32F4xx.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c.c
    RTE/Device/STM32F407VGTx/: RTE_Device.h startup_stm32f407xx.s stm32f4xx_hal_conf.h system_stm32f4xx.c
  group ::USB
    C:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.1.1/USB/Lib/ARM/: USB_CM3_L.lib
    RTE/USB/: USBD_Config_0.c USBD_Config_CDC_0.h
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, USB:CORE 6.1.0, USB:Device 6.1.0, USB:Device:CDC 6.1.0, CMSIS Driver:USB Device:Full-speed 2.02, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:I2C 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:Startup 2.1.0
